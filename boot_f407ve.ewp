# IAR project boot_f407ve.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: drivers; hal_drivers\CMSIS\Device\ST\STM32F4xx\Include; hal_drivers\CMSIS\Include; hal_drivers\STM32F4xx_HAL_Driver\Inc; newbee; ..\..\include; ..\..\include\libc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: boot_f407ve.hex
  ILINK.IlinkOutputFile: boot_f407ve.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drivers
    drivers/: board.c drv_fyyp.c drv_hex.c drv_lpm.c drv_mempool.c drv_pin.c drv_w25qxxx.c
  group hal_drivers/cmsis
    hal_drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    hal_drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group hal_drivers/periph_drivers
    hal_drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group newbee
    newbee/: main.c stm32f4xx_it.c
  group rtthread/port
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group rtthread/src
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
